# Keil uVision project app_ota.uvprojx, settings and files
target app_ota (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: app_ota +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,OTA_APP_RELOCATE_VECTOR=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HARDWARE/24CXX;../HARDWARE/IIC;../HARDWARE/LCD;../HARDWARE/RS485;../HARDWARE/TOUCH;../HARDWARE/W25QXX;../HARDWARE;../LVGL/src;../LVGL/src/core;../LVGL/src/draw;../LVGL/src/draw/sw;../LVGL/src/font;../LVGL/src/hal;../LVGL/src/misc;../LVGL/src/extra;../LVGL/src/extra/themes/default;../LVGL/src/extra/themes/basic;../../ai_project;../HARDWARE/LVGL;../LVGL/src/widgets;../LVGL/src/extra/layouts/flex;../LVGL/src/extra/layouts/grid;../LVGL/src/extra/widgets/tabview;../LVGL/src/extra/widgets/tileview;../LVGL/src/extra/widgets/win;../LVGL/src/extra/widgets/spinbox;../LVGL/src/extra/widgets/spinner;../LVGL/src/extra/widgets/menu;../LVGL/src/extra/widgets/meter;../LVGL/src/extra/widgets/msgbox;../LVGL/src/extra/widgets/list;../LVGL/src/extra/widgets/calendar;../LVGL/src/extra/widgets/chart;../LVGL/src/extra/widgets/colorwheel;../LVGL/src/extra/widgets/keyboard;../LVGL/src/extra/widgets/led;../HARDWARE/ESP8266;../TEXT;../MALLOC;../FATFS/src;../FATFS/exfuns;../HARDWARE/SDIO;..\HARDWARE\ROBOT_FACE;..\HARDWARE\ASR_PRO;..\HARDWARE\aht20_bmp280;..\HARDWARE\LED;..\HARDWARE\WEB_SERVER
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: app_ota.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c freertos.c dma.c fsmc.c sdio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c main.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/TOUCH/: ctiic.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/: delay.c
    ../HARDWARE/LVGL/: lv_port_disp.c lv_port_indev.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/ROBOT_FACE/: robot_face_anim.c
    ../HARDWARE/ASR_PRO/: asr_pro.c
    ../HARDWARE/aht20_bmp280/: ATH20.c BMP280.c bsp_i2c.c
    ../HARDWARE/LED/: led_breath.c
    ../HARDWARE/WEB_SERVER/: web_server.c
  group LVGL/src
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_montserrat_40.c lv_font_montserrat_14.c lv_font_cjk16.c lv_font_punct16.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/widgets/: lv_label.c lv_btn.c lv_textarea.c lv_btnmatrix.c lv_img.c lv_switch.c lv_table.c lv_arc.c lv_roller.c lv_slider.c lv_bar.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_line.c lv_objx_templ.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
  group CN
    ../TEXT/: fontupd.c text.c
    ../MALLOC/: malloc.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c
    ../LVGL/src/font/: lv_font_cjk16_sd.c
software components: CMSIS:CORE 4.3.0
