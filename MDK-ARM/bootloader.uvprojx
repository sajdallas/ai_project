# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,BOOTLOADER_SD_SAFE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HARDWARE/24CXX;../HARDWARE/IIC;../HARDWARE/LCD;../HARDWARE/RS485;../HARDWARE/TOUCH;../HARDWARE/W25QXX;../HARDWARE;../LVGL/src;../LVGL/src/core;../LVGL/src/draw;../LVGL/src/draw/sw;../LVGL/src/font;../LVGL/src/hal;../LVGL/src/misc;../LVGL/src/extra;../LVGL/src/extra/themes/default;../LVGL/src/extra/themes/basic;../../ai_project;../HARDWARE/LVGL;../LVGL/src/widgets;../LVGL/src/extra/layouts/flex;../LVGL/src/extra/layouts/grid;../LVGL/src/extra/widgets/tabview;../LVGL/src/extra/widgets/tileview;../LVGL/src/extra/widgets/win;../LVGL/src/extra/widgets/spinbox;../LVGL/src/extra/widgets/spinner;../LVGL/src/extra/widgets/menu;../LVGL/src/extra/widgets/meter;../LVGL/src/extra/widgets/msgbox;../LVGL/src/extra/widgets/list;../LVGL/src/extra/widgets/calendar;../LVGL/src/extra/widgets/chart;../LVGL/src/extra/widgets/colorwheel;../LVGL/src/extra/widgets/keyboard;../LVGL/src/extra/widgets/led;../HARDWARE/ESP8266;../TEXT;../MALLOC;../FATFS/src;../FATFS/exfuns;../HARDWARE/SDIO;..\HARDWARE\ROBOT_FACE;..\HARDWARE\ASR_PRO;..\HARDWARE\aht20_bmp280
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\Bootloader\bootloader.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Bootloader
    ../Bootloader/: main_bootloader.c bootloader.c boot_clock.c boot_it.c boot_diskio.c
  group Core
    ../Core/Src/: gpio.c dma.c sdio.c stm32f4xx_hal_msp.c system_stm32f4xx.c usart.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_sdmmc.c
  group FatFS
    ../FATFS/src/: ff.c
  group HARDWARE
    ../HARDWARE/SDIO/: sdio_sdcard.c
software components: CMSIS:CORE 4.3.0
